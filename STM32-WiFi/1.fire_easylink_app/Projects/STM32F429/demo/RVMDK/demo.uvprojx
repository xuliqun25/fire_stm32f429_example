# Keil uVision project demo.uvprojx, settings and files
target MICO-Fire (ARM-ADS)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mdk_demo.axf +hex
  AfterMake: fromelf.exe --bin  ..\..\..\..\Build\demo\MICO-Fire_F429\obj_RVMDK\mdk_demo.axf --output ..\..\..\..\Build\demo\Output\Fire_F429\mdk_demo.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER DEBUG HSE_VALUE=25000000 MICO_FIRE_F429
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\Demos\fire\AppFramework;..\..\..\..\Demos\fire\ov2640;..\..\..\..\Demos\fire\user_fog;..\..\..\..\Demos\fire;..\..\..\..\Board\fire_F429;..\..\..\..\include;..\..\..\..\include\FogCloud;..\..\..\..\libraries\utilities;..\..\..\..\libraries\utilities\json_c;..\..\..\..\libraries\protocols\fog_cloud;..\..\..\..\MICO\core;..\..\..\..\MICO\security;..\..\..\..\MICO\system;..\..\..\..\MICO\system\command_console;..\..\..\..\Platform\include;..\..\..\..\Platform\Cortex-M4;..\..\..\..\Platform\Cortex-M4\CMSIS;..\..\..\..\Platform\MCU\STM32F4xx\peripherals;..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries;..\..\..\..\Platform\MCU\STM32F4xx\wlan_bus_driver;..\..\..\..\Platform\Drivers\spi_flash;..\..\..\..\Platform\Drivers;..\..\..\..\libraries\daemons\homekit_server;..\..\..\..\libraries\daemons\http_server;..\..\..\..\Platform\Drivers\ov2640;..\..\..\..\Platform\Drivers\malloc;..\..\..\..\Platform\Drivers\SDRAM;..\..\..\..\Platform\Drivers\beep;..\..\..\..\Platform\Drivers\sensor\light_adc;..\..\..\..\Platform\Drivers\sensor\RHEOSTAT;..\..\..\..\Platform\Drivers\sensor\DHT11;..\..\..\..\Platform\Drivers\rgb_led\fire_rgb_led
  memory RVCT4: ROM 0x8010000 size 0xefffff
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_warning=6218,6654,6238 --diag_suppress=6238
  group app/AppFramework
    ../../../../Demos/fire/AppFramework/: fogCloud.c fogCloud.h fogcloud_msg_dispatch.c fogcloud_msg_dispatch.h MICOAppDefine.h MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c MicoFogCloud.c MicoFogCloud.h MicoFogCloudConfigServer.c MicoFogCloudDef.h properties.c properties.h
  group app/user/ov2640
    ../../../../Demos/fire/ov2640/: camera_data_queue.c camera_data_queue.h camera_server.c camera_server.h tcp_server.c tcp_server.h
  group app/user/user_fog
    ../../../../Demos/fire/user_fog/: fogcloud_down_thread.c fogcloud_down_thread.h fogcloud_up_thread.c fogcloud_up_thread.h uart_recv_thread.c uart_recv_thread.h
  group app/user
    ../../../../Demos/fire/: fire_demo.c mico_config.h user_config.h
  group Board/fire-F429
    ../../../../Board/fire_F429/: platform.c platform.h platform_config.h
  group Include
    ../../../../include/: MICO.h MicoAES.h MicoSRPServer.h Common.h Debug.h mico_platform.h mico_rtos.h mico_security.h mico_socket.h mico_system.h mico_wlan.h
  group Include/MicoDriver
    ../../../../include/MicoDrivers/: MicoDriverAdc.h MicoDriverFlash.h MicoDriverGpio.h MicoDriverI2c.h MicoDriverMFiAuth.h MICODriverNanoSecond.h MicoDriverPwm.h MicoDriverRng.h MicoDriverRtc.h MicoDriverSpi.h MicoDriverUart.h MicoDriverWdg.h
  group Libraries/utilities
    ../../../../libraries/utilities/: AESUtils.c AESUtils.h CheckSumUtils.c CheckSumUtils.h HTTPUtils.c HTTPUtils.h RingBufferUtils.c RingBufferUtils.h SecurityUtils.c SecurityUtils.h SHAUtils.c SHAUtils.h SocketUtils.c SocketUtils.h StringUtils.c StringUtils.h TimeUtils.c TimeUtils.h TLVUtils.c TLVUtils.h URLUtils.c URLUtils.h
  group libraries/http_server
    ../../../../libraries/daemons/http_server/: http_parse.c httpd.c httpd_handle.c httpd_ssi.c httpd_sys.c httpd_wsgi.c http-strings.c
  group Libraries/utilities/jscon_c
    ../../../../libraries/utilities/json_c/: arraylist.c arraylist.h bits.h config.h debug.c debug.h json.h json_inttypes.h json_object.c json_object.h json_object_private.h json_tokener.c json_tokener.h json_util.c json_util.h linkhash.c linkhash.h printbuf.c printbuf.h
  group libraries/protocols/fog_cloud
    ../../../../libraries/protocols/fog_cloud/: FogCloudMQTTClient.c FogCloudMQTTClient.h FogCloudService.c FogCloudService.h FogCloudServiceDef.h FogCloudServiceVersion.c FogCloudUtils.c FogCloudUtils.h MQTTClient.c MQTTClient.h MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTMICO.c MQTTMICO.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
  group MICO/core
    ../../../../MICO/core/: mico_config.c mxchipWNet_cm4f_sdio.a mxchipWNet_cm4f_spi.a
    ../../../../MICO/core/RF driver/: wlan_firmware.c
  group MICO/security
    ../../../../MICO/security/: MicoCrypto.a
    ../../../../mico/security/SHAUtils/: hkdf.c hmac.c sha1.c sha224-256.c sha384-512.c usha.c
    ../../../../mico/security/Curve25519/: curve25519-donna.c
    ../../../../mico/security/: MicoSrpServer.a
  group MICO/system
    ../../../../MICO/system/command_console/: mico_cli.c
    ../../../../MICO/system/config_server/: config_server.c config_server_menu.c
    ../../../../MICO/system/easylink/: system_easylink.c system_easylink_delegate.c system_easylink_wac.c
    ../../../../MICO/system/mdns/: mico_mdns.c
    ../../../../MICO/system/tftp_ota/: tftp.h tftp_ota.c tftp_ota.h tftpc.o
    ../../../../MICO/system/: mico_system_init.c mico_system_monitor.c mico_system_notification.c mico_system_para_storage.c mico_system_power_daemon.c system.h system_factory_test.c system_misc.c
    ../../../../mico/system/easylink/: libMFiWAC.a
    ../../../../mico/system/easylink/airkiss_discovery/: airkiss_discovery.c
    ../../../../mico/system/easylink/airkiss_discovery/lib_airkiss/: libairkiss_KEIL.a
    ../../../../mico/system/mdns/: system_discovery.c
  group Platform/Cortex-M4
    ../../../../Platform/Cortex-M4/: crt0_RVMDK.c hardfault.c
  group Platform/RVMDK
    ../../../../Platform/RVMDK/: Retarget.c thread_safe.c memory_debugger.lib memory_debugger.c
  group Platform/Drivers/MFiAuth
    ../../../../Platform/Drivers/MicoDriverMFiAuth/: MicoDriverMFiAuth.a
  group Platform/Drivers/SPI_Flash
    ../../../../Platform/Drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group Platform/Drivers/Button
    ../../../../Platform/Drivers/keypad/gpio_button/: button.c
  group Platform/MCU
    ../../../../Platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/MCU/STM32F4xx
    ../../../../Platform/MCU/STM32F4xx/: platform_init.c
  group Platform/MCU/STM32F4xx/RVMDK
    ../../../../Platform/MCU/STM32F4xx/RVMDK/: startup_stm32f429_RVMDK.s
  group Platform/MCU/STM32F4xx/wlan_bus_driver
    ../../../../Platform/MCU/STM32F4xx/wlan_bus_driver/: wlan_bus_sdio.c wlan_bus_spi.c wlan_platform.c
  group Platform/MCU/STM32F4xx/peripherals/Libraries
    ../../../../Platform/MCU/STM32F4xx/peripherals/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_fmc.c
  group Platform/MCU/STM32F4xx/peripherals
    ../../../../Platform/MCU/STM32F4xx/peripherals/: paltform_rtc.c platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_powersave.c platform_nano_second.c platform_pwm.c platform_rng.c platform_spi.c platform_uart.c platform_watchdog.c
  group Platform/Drivers/OV2640
    ../../../../Platform/Drivers/ov2640/: ov2640_Init.c ov2640_reg.h ov2640_SCCB.c
  group Platform/Drivers/malloc
    ../../../../Platform/Drivers/malloc/: malloc.c malloc.h
  group Platform/Drivers/sdram
    ../../../../Platform/Drivers/SDRAM/: bsp_sdram.c bsp_sdram.h
  group Platform/Drivers/beep
    ../../../../Platform/Drivers/beep/: fire_beep.c fire_beep.h
  group Platform/Drivers/rheostat
    ../../../../Platform/Drivers/sensor/RHEOSTAT/: rheostat.c rheostat.h
  group Platform/Drivers/light_adc
    ../../../../Platform/Drivers/sensor/light_adc/: light_sensor.c light_sensor.h
  group Platform/Drivers/dht11
    ../../../../Platform/Drivers/sensor/DHT11/: DHT11.c DHT11.h
  group Platform/Drivers/fire_grb_led
    ../../../../Platform/Drivers/rgb_led/fire_rgb_led/: fire_rgb_led.c fire_rgb_led.h
