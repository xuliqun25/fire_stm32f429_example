# IAR project fire_F429.ewp, settings and files
configuration fire_F429 (ARM)
  General.OGChipSelectEditMenu: STM32F429IG ST STM32F429IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; HSE_VALUE=25000000; STM32F429_439xx; MICO_FIRE_F429
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\include; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\fire_F429; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\Platform\Drivers; ..\..\..\..\Platform\Drivers\SDRAM; ..\..\..\..\Platform\Drivers\malloc; ..\..\..\..\Platform\Drivers\ov2640; ..\..\..\..\Platform\Drivers\rgb_led\fire_rgb_led; ..\..\..\..\Platform\Drivers\beep; ..\..\..\..\mico\system; ..\..\..\..\libraries\utilities\json_c; ..\..\..\..\libraries\utilities; ..\..\..\..\libraries\daemons\http_server; ..\..\..\..\mico\security; ..\..\..\..\libraries\daemons\homekit_server; ..\..\..\..\include\FogCloud; ..\..\..\..\Demos\fire\ov2640; ..\..\..\..\Demos\fire\ov2640; ..\..\..\..\Demos\fire\AppFramework; ..\..\..\..\Demos\fire; ..\..\..\..\Demos\fire\user_fog; ..\..\..\..\libraries\protocols\fog_cloud
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: iar_demo.bin
  ILINK.IlinkOutputFile: fire_F429.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\fire_F429\micoLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app_fire/AppFramework
    ../../../../Demos/fire/AppFramework/: fogCloud.c fogCloud.h fogcloud_msg_dispatch.c fogcloud_msg_dispatch.h MICOAppDefine.h MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c MicoFogCloud.c MicoFogCloud.h MicoFogCloudConfigServer.c MicoFogCloudDef.h properties.c properties.h
  group app_fire/user
    ../../../../Demos/fire/: fire_demo.c mico_config.h user_config.h
  group app_fire/user/ov2640
    ../../../../Demos/fire/ov2640/: camera_data_queue.c camera_data_queue.h camera_server.c camera_server.h tcp_server.c tcp_server.h
  group app_fire/user/user_fog
    ../../../../Demos/fire/user_fog/: fogcloud_down_thread.c fogcloud_down_thread.h fogcloud_up_thread.c fogcloud_up_thread.h uart_recv_thread.c uart_recv_thread.h
  group app_fire_ext
    ../../../../Demos/fire_ext/: reb_led.c user_DHT11.c user_light.c user_rheostat.c
  group app_fire_ext/user_uart
    ../../../../Demos/fire_ext/user_uart/: user_uart.c user_uart.h
  group app_tcp_speed_test
    ../../../../Demos/wifi/station/: wifi_station_core_api_1.c
  group Board/fire_F429
    ../../../../Board/fire_F429/: platform.c platform.h platform_config.h
  group include
    ../../../../include/: Common.h Debug.h MICO.h mico_platform.h mico_rtos.h mico_security.h mico_socket.h mico_system.h mico_wlan.h
  group include/fogcloud
    ../../../../include/FogCloud/: FogCloudService.h FogCloudServiceDef.h FogCloudUtils.h
  group include/MicoDriver
    ../../../../include/MicoDrivers/: MicoDriverAdc.h MicoDriverGpio.h MicoDriverI2c.h MicoDriverMFiAuth.h MicoDriverPwm.h MicoDriverRng.h MicoDriverRtc.h MicoDriverSpi.h MicoDriverUart.h MicoDriverWdg.h
  group libraries/daemons/http_server
    ../../../../libraries/daemons/http_server/: http-strings.c http-strings.h http_parse.c http_parse.h httpd.c httpd.h httpd_handle.c httpd_priv.h httpd_ssi.c httpd_sys.c httpd_wsgi.c
  group libraries/protocols/fogcloud
    ../../../../libraries/protocols/fog_cloud/: FogCloud_cm4_debug.a FogCloud_cm4_release.a FogCloudMQTTClient.c FogCloudMQTTClient.h FogCloudService.c FogCloudService.h FogCloudServiceDef.h FogCloudServiceVersion.c FogCloudUtils.c FogCloudUtils.h MQTTClient.c MQTTClient.h MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTMICO.c MQTTMICO.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
  group libraries/utilities
    ../../../../libraries/utilities/: AESUtils.c CheckSumUtils.c HTTPUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
  group libraries/utilities/json_c
    ../../../../libraries/utilities/json_c/: arraylist.c arraylist.h bits.h config.h debug.c debug.h json.h json_inttypes.h json_object.c json_object.h json_object_private.h json_tokener.c json_tokener.h json_util.c json_util.h linkhash.c linkhash.h printbuf.c printbuf.h
  group mico/core
    ../../../../MICO/core/: mico_config.c mxchipWNet_cm4f_sdio.a mxchipWNet_cm4f_spi.a
    ../../../../mico/core/: mxchipWNet_cm4f_8801.a
    ../../../../MICO/core/RF driver/: wlan_firmware.c
  group mico/security
    ../../../../MICO/security/: MicoCrypto.a MicoSrpServer.a
  group mico/security/curve25519
    ../../../../MICO/security/Curve25519/: curve25519-donna.c
  group mico/security/SHA
    ../../../../MICO/security/SHAUtils/: hkdf.c hmac.c sha1.c sha224-256.c sha384-512.c usha.c
  group mico/system
    ../../../../MICO/system/config_server/: config_server.c config_server_menu.c
    ../../../../MICO/system/command_console/: mico_cli.c mico_cli.h
    ../../../../MICO/system/: mico_system_init.c mico_system_monitor.c mico_system_notification.c mico_system_para_storage.c mico_system_power_daemon.c system.h system_factory_test.c system_misc.c
    ../../../../MICO/system/tftp_ota/: tftp.h tftp_ota.c tftp_ota.h tftpc.o
  group mico/system/easylink
    ../../../../MICO/system/easylink/airkiss_discovery/: airkiss_discovery.c
    ../../../../MICO/system/easylink/airkiss_discovery/lib_airkiss/: libairkiss.a
    ../../../../MICO/system/easylink/: libMFiWAC.a system_easylink.c system_easylink_delegate.c system_easylink_wac.c
  group mico/system/mdns
    ../../../../MICO/system/mdns/: mico_mdns.c mico_mdns.h system_discovery.c
  group Platform
    ../../../../Platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/Cortex-M4
    ../../../../Platform/Cortex-M4/: crt0_EWARM.c hardfault.c
  group Platform/Drivers/beep
    ../../../../Platform/Drivers/beep/: fire_beep.c fire_beep.h
  group Platform/Drivers/display/VGM128064
    ../../../../Platform/Drivers/display/VGM128064/: AsciiLib.c AsciiLib.h oled.c oled.h oledfont.h
  group Platform/Drivers/keypad/gpio_button
    ../../../../Platform/Drivers/keypad/gpio_button/: button.c button.h
  group Platform/Drivers/led/fire_rgb_led
    ../../../../Platform/Drivers/rgb_led/fire_rgb_led/: fire_rgb_led.c fire_rgb_led.h
  group Platform/Drivers/led/P9813
    ../../../../Platform/Drivers/rgb_led/P9813/: hsb2rgb_led.c hsb2rgb_led.h rgb_led.c rgb_led.h
  group Platform/Drivers/malloc
    ../../../../Platform/Drivers/malloc/: malloc.c malloc.h
  group Platform/Drivers/MFiAuth
    ../../../../Platform/Drivers/MicoDriverMFiAuth/: MicoDriverMFiAuth.a
  group Platform/Drivers/MiCOKit-EXT
    ../../../../Platform/Drivers/MiCOKit_EXT/: micokit_ext.c micokit_ext.h micokit_ext_def.h micokit_ext_mfg.c motion_sensor.c motion_sensor.h temp_hum_sensor.c
  group Platform/Drivers/MiCOKit-STmem
    ../../../../Platform/Drivers/MiCOKit_STmems/: MiCOKit_STmems.c MiCOKit_STmems.h MiCOKit_STmems_def.h
  group Platform/Drivers/motor/dc_motor
    ../../../../Platform/Drivers/motor/dc_motor/: dc_motor.c dc_motor.h
  group Platform/Drivers/ov2640
    ../../../../Platform/Drivers/ov2640/: ov2640_Init.c ov2640_Init.h ov2640_reg.h ov2640_SCCB.c
  group Platform/Drivers/sdram
    ../../../../Platform/Drivers/SDRAM/: bsp_sdram.c bsp_sdram.h
  group Platform/Drivers/sensor/ADPS9930
    ../../../../Platform/Drivers/sensor/apds9930/: apds9930.c apds9930.h
  group Platform/Drivers/sensor/BMA2x2
    ../../../../Platform/Drivers/sensor/BMA2x2/: bma2x2.c bma2x2.h bma2x2_user.c bma2x2_user.h
  group Platform/Drivers/sensor/BME280
    ../../../../Platform/Drivers/sensor/BME280/: bme280.c bme280.h bme280_user.c bme280_user.h
  group Platform/Drivers/sensor/BMG160
    ../../../../Platform/Drivers/sensor/BMG160/: bmg160.c bmg160.h bmg160_user.c bmg160_user.h
  group Platform/Drivers/sensor/BMM050
    ../../../../Platform/Drivers/sensor/BMM050/: bmm050.c bmm050.h bmm050_user.c bmm050_user.h
  group Platform/Drivers/sensor/DHT11
    ../../../../Platform/Drivers/sensor/DHT11/: DHT11.c DHT11.h
  group Platform/Drivers/sensor/HTS221
    ../../../../Platform/Drivers/sensor/HTS221/: hts221.c hts221.h
  group Platform/Drivers/sensor/infrared_adc
    ../../../../Platform/Drivers/sensor/infrared_adc/: infrared_reflective.c infrared_reflective.h
  group Platform/Drivers/sensor/light_adc
    ../../../../Platform/Drivers/sensor/light_adc/: light_sensor.c light_sensor.h
  group Platform/Drivers/sensor/LPS25HB
    ../../../../Platform/Drivers/sensor/LPS25HB/: lps25hb.c lps25hb.h
  group Platform/Drivers/sensor/LSM9DS1
    ../../../../Platform/Drivers/sensor/LSM9DS1/: lsm9ds1.h lsm9ds1_acc_gyr.c lsm9ds1_mag.c
  group Platform/Drivers/sensor/RHEOSTAT
    ../../../../Platform/Drivers/sensor/RHEOSTAT/: rheostat.c rheostat.h
  group Platform/Drivers/sensor/UVIS25
    ../../../../Platform/Drivers/sensor/UVIS25/: uvis25.c uvis25.h
  group Platform/Drivers/SPI Flash
    ../../../../Platform/Drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group Platform/Drivers/SSD2543
    ../../../../Platform/Drivers/SSD2543/: SSD2543.c SSD2543.h
  group Platform/EWARM
    ../../../../Platform/EWARM/: Retarget.c
  group Platform/STM32F4xx
    ../../../../Platform/MCU/STM32F4xx/: platform_init.c
  group Platform/STM32F4xx/EWARM
    ../../../../Platform/MCU/STM32F4xx/EWARM/: startup_stm32f429IG_IAR.s
  group Platform/STM32F4xx/Peripherals
    ../../../../Platform/MCU/STM32F4xx/peripherals/: paltform_rtc.c platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_powersave.c platform_nano_second.c platform_pwm.c platform_rng.c platform_spi.c platform_uart.c platform_watchdog.c
  group Platform/STM32F4xx/Peripherals/Libraries
    ../../../../Platform/MCU/STM32F4xx/peripherals/Libraries/: stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.c system_stm32f4xx.h
  group Platform/STM32F4xx/Peripherals/Libraries/STM32F4xx_StdPeriph_Driver/inc
    ../../../../Platform/MCU/STM32F4xx/peripherals/Libraries/STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group Platform/STM32F4xx/Peripherals/Libraries/STM32F4xx_StdPeriph_Driver/src
    ../../../../Platform/MCU/STM32F4xx/peripherals/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Platform/STM32F4xx/Wi-Fi_Bus_Driver
    ../../../../Platform/MCU/STM32F4xx/wlan_bus_driver/: wlan_bus_sdio.c wlan_bus_spi.c wlan_platform.c
